# Keil uVision project Wifi-DEMO.uvprojx, settings and files
target Wifi-DEMO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\mcu_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe008
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c key.c led.c Time_test.c usart3.c SysTick.c flash.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group mcu_sdk
    ../mcu_sdk/: at_parse.c download.c mcu_at_system.c tsl_protocol.c
